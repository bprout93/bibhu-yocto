require nss.inc

SRC_URI += "\
    http://ftp.mozilla.org/pub/mozilla.org/security/nss/releases/NSS_3_28_6_RTM/src/${BP}.tar.gz \
"
SRC_URI[md5sum] = "673370799f8e88e41723d4a72f47510b"
SRC_URI[sha256sum] = "2467931b882146cdea81edae6acb6fb9abf11be3ed94fcb30462187b51276aca"
